# Keil uVision project prod_test.uvproj, settings and files
target prod_test (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: prod_test +hex
  AfterMake: hex2bin out\prod_test.hex
  c flags: Optim=4 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h
  c include: .\.;.\..\..\..\src\dialog\include;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\..\..\src\plf\refip\src\arch;.\..\..\..\src\plf\refip\src\arch\compiler\rvds;.\..\..\..\src\plf\refip\src\arch\boot\rvds;.\..\..\..\src\plf\refip\src\arch\ll\rvds;.\..\..\..\src\plf\refip\src\driver\reg;.\..\..\..\src\modules\common\api;.\..\..\..\src\modules\dbg\api;.\..\..\..\src\modules\display\api;.\..\..\..\src\modules\gtl\api;.\..\..\..\src\modules\ke\api;.\..\..\..\src\modules\ke\src;.\..\..\..\src\modules\nvds\api;.\..\..\..\src\modules\rf\api;.\..\..\..\src\modules\rwip\api;.\..\..\..\src\ip\ble\ll\src\rwble;.\..\..\..\src\ip\ble\ll\src\controller\em;.\..\..\..\src\ip\ble\ll\src\controller\llc;.\..\..\..\src\ip\ble\ll\src\controller\lld;.\..\..\..\src\ip\ble\ll\src\controller\llm;.\..\..\..\src\plf\refip\src\driver\led;.\..\..\..\src\plf\refip\src\driver\timer;.\..\..\..\src\plf\refip\src\driver\syscntl;.\..\..\..\src\plf\refip\src\driver\emi;.\..\..\..\src\plf\refip\src\driver\uart;.\..\..\..\src\plf\refip\src\driver\flash;.\..\..\..\src\plf\refip\src\driver\gpio;.\..\..\..\src\ip\ble\hl\src\host\att;.\..\..\..\src\ip\ble\hl\src\host\att\attc;.\..\..\..\src\ip\ble\hl\src\host\att\attm;.\..\..\..\src\ip\ble\hl\src\host\gap;.\..\..\..\src\ip\ble\hl\src\host\gap\gapc;.\..\..\..\src\ip\ble\hl\src\host\gap\gapm;.\..\..\..\src\ip\ble\hl\src\host\att\atts;.\..\..\..\src\ip\ble\hl\src\host\gatt;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattc;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattm;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cc;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cm;.\..\..\..\src\ip\ble\hl\src\host\smp\smpc;.\..\..\..\src\ip\ble\hl\src\host\smp\smpm;.\..\..\..\src\ip\ble\hl\src\profiles;.\..\..\..\src\ip\ble\hl\src\profiles\accel;.\..\..\..\src\ip\ble\hl\src\profiles\bas\basc;.\..\..\..\src\ip\ble\hl\src\profiles\bas\bass;.\..\..\..\src\ip\ble\hl\src\profiles\blp;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blpc;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blps;.\..\..\..\src\ip\ble\hl\src\profiles\dis\disc;.\..\..\..\src\ip\ble\hl\src\profiles\dis\diss;.\..\..\..\src\ip\ble\hl\src\profiles\find\findl;.\..\..\..\src\ip\ble\hl\src\profiles\find\findt;.\..\..\..\src\ip\ble\hl\src\profiles\hogp;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpbh;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpd;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogprh;.\..\..\..\src\ip\ble\hl\src\profiles\hrp;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrpc;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrps;.\..\..\..\src\ip\ble\hl\src\profiles\htp;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpc;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpt;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxm;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxr;.\..\..\..\src\ip\ble\hl\src\profiles\scpp;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scppc;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scpps;.\..\..\..\src\plf\refip\src\driver\intc;.\..\..\..\src\ip\ble\hl\src\rwble_hl;.\..\..\..\src\ip\ble\ll\src\hcic;.\..\..\..\src\ip\ble\hl\src\host\smp;.\..\..\..\src\modules\app\api;.\..\..\..\src\modules\gtl\src;.\..\..\..\src\ip\ble\hl\src\profiles\anp;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anpc;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anps;.\..\..\..\src\ip\ble\hl\src\profiles\cscp;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscpc;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscps;.\..\..\..\src\ip\ble\hl\src\profiles\glp;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glpc;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glps;.\..\..\..\src\ip\ble\hl\src\profiles\pasp;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\paspc;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\pasps;.\..\..\..\src\ip\ble\hl\src\profiles\rscp;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscpc;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscps;.\..\..\..\src\ip\ble\hl\src\profiles\tip;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tipc;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tips;.\..\..\..\src\modules\app\src;..\..\..\src\modules\app\src\app_project\prod_test\;..\..\..\src\modules\app\src\app_project\prod_test\system;.\..\..\..\src\plf\refip\src\driver\adc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: ..\..\..\scatterfiles\scatterfile_prodtest_580.sct
  link misc: ..\..\..\misc\rom_symdef_ES5_Prod_Test.txt  --symdefs=prod_test_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group boot
    ./../../../src/plf/refip/src/arch/boot/rvds/: system_ARMCM0.c
    ../../../src/plf/refip/src/arch/boot/rvds/: boot_vectors.s
  group arch
    ./../../../src/plf/refip/src/arch/main/ble/: arch_main.c jump_table.c
    ../../../src/plf/refip/src/arch/main/ble/: nmi_handler.c arch_sleep.c hardfault_handler.c arch_system.c arch_patch.c
    ../../../src/modules/app/src/app_project/prod_test/system/: periph_setup.c
  group patches
    ../../../patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj
  group driver
    ../../../src/plf/refip/src/driver/syscntl/: syscntl.c
    ./../../../src/modules/rf/src/: rf_580.c
    ../../../src/plf/refip/src/driver/adc/: adc.c
    ../../../src/plf/refip/src/driver/gpio/: gpio.c
  group host
    ./../../../src/ip/ble/hl/src/host/gap/gapm/: gapm.c
  group nvds
    ../../../src/modules/nvds/src/: nvds.c
  group rwble
    ./../../../src/ip/ble/ll/src/rwble/: rwble.c
    ../../../src/modules/rwip/src/: rwip.c
  group misc
    ../../../misc/: rom_symdef_ES5_Prod_Test.txt
  group app
    ../../../src/modules/app/src/app_project/prod_test/: customer_prod.c custom_lld_evt.c custom_lld_data.c custom_lld.c custom_gtl_eif.c custom_gtl_hci.c xtal_cal.c pulse.s rdtest_api.c rdtest_lowlevel.c rdtest_support.c
