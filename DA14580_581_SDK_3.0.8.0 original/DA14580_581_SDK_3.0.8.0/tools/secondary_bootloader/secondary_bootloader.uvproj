# Keil uVision project secondary_bootloader.uvproj, settings and files
target secondary_bootloader (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: secondary_bootloader +hex
  c flags: Optim=4
  c misc: --c99
  c include: .\includes;..\..\dk_apps\src\dialog\include;..\..\dk_apps\src\plf\refip\src\driver\spi;..\..\dk_apps\src\plf\refip\src\driver\i2c_eeprom;..\..\dk_apps\src\plf\refip\src\driver\spi_flash;..\..\dk_apps\src\plf\refip\src\driver\gpio;..\..\dk_apps\src\plf\refip\src\arch;..\..\dk_apps\src\plf\refip\src\arch\compiler\rvds;..\..\dk_apps\src\plf\refip\src\arch\ll\rvds;..\..\dk_apps\src\plf\refip\src\driver\reg
  asm include: .\includes
  library: MicroLIB
  scatter file: .\startup\bootloader.sct
  group boot
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group src
    ./src/: bootloader.c timer.c uart.c main.c uart_booter.c spi_commands.c crc32.c sw_aes.c
    ../../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.c
    ../../dk_apps/src/plf/refip/src/driver/spi/: spi.c
    ../../dk_apps/src/plf/refip/src/driver/gpio/: gpio.c
    ../../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
  group includes
    ./includes/: periph_setup.h timer.h uart.h uart_booter.h bootloader.h spi_commands.h os_int.h os_port.h sw_aes.h
    ../../dk_apps/src/dialog/include/: datasheet.h global_io.h
    ../../dk_apps/src/plf/refip/src/driver/spi/: spi.h
    ../../dk_apps/src/plf/refip/src/driver/spi_flash/: spi_flash.h
    ../../dk_apps/src/plf/refip/src/driver/gpio/: gpio.h
    ../../dk_apps/src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.h
